** sch_path: designs/libs/current_reference_generator_v2/cace/templates/current_reference_generator_v2_CACE_mc.sch
**.subckt current_reference_generator_v2_CACE_mc
R1 V_rext VSS 600k tc1=200e-6 m=1
V1 VSS GND 0
V3 VDD GND CACE{VDD}
V5 Vref GND CACE{Vref}
x2 net3 net1 net4 net6 VDD VSS net2 net5 current_reference_load_v2
x1 VSS VDD Vref Vrefp Vrefn net3 net1 net4 net6 V_rext net2 net5 current_reference_generator_v2
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control
.param sw_stat_global = 1
.param sw_stat_mismatch = 1
save all

*OP simulation
op

*TOP

let Iref_2n = @m.x2.xm1.m0[id]
let Iref_20n = @m.x2.xm2.m0[id]
let Iref_50n = @m.x2.xm3.m0[id]
let Iref_2p = @m.x2.xm4.m0[id]
let Iref_20p = @m.x2.xm5.m0[id]
let Iref_50p = @m.x2.xm6.m0[id]

set wr_singlescale
echo $&Iref_2n $&Iref_20n $&Iref_50n $&Iref_2p $&Iref_20p $&Iref_50p > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
