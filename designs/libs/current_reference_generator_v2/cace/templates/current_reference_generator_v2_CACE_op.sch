** sch_path: designs/libs/current_reference_generator_v2/cace/templates/current_reference_generator_v2_CACE_op.sch
**.subckt current_reference_generator_v2_CACE_op
V1 VSS GND 0
V3 net1 GND CACE{VDD}
V5 Vref GND CACE{Vref}
vdd_i net1 VDD 0
.save i(vdd_i)
R1 V_rext VSS 600k tc1=200e-6 m=1
x1 VSS VDD Vref Vrefp Vrefn net4 net2 net5 net7 V_rext net3 net6 current_reference_generator_v2
x2 net4 net2 net5 net7 VDD VSS net3 net6 current_reference_load_v2
**** begin user architecture code


.control
save all

*OP simulation
op

*TOP

let Iref_2n = @m.x2.xm1.m0[id]
let Iref_20n = @m.x2.xm2.m0[id]
let Iref_50n = @m.x2.xm3.m0[id]
let Iref_2p = @m.x2.xm4.m0[id]
let Iref_20p = @m.x2.xm5.m0[id]
let Iref_50p = @m.x2.xm6.m0[id]
let Iqscnt= i(vdd_i) - (Iref_2n + Iref_20n + Iref_50n + Iref_2p + Iref_20p + Iref_50p)

set wr_singlescale
echo $&Iref_2n $&Iref_20n $&Iref_50n $&Iref_2p $&Iref_20p $&Iref_50p $&Iqscnt > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
