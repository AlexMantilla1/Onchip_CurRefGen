** sch_path: designs/libs/current_reference_load_v2/cace/templates/CR_loads_jangarita.sch
**.subckt CR_loads_jangarita
x1 Iref1n net1 Iref1p net2 VDD VSS Iref10n Iref10p current_reference_load_v2
I4 Iref1n VSS 1u
VSN VSS GND 0
VSP VDD GND CACE{VDD}
I1 VDD Iref1p 1u
I2 VDD Iref10p 10u
I3 Iref10n VSS 10u
**** begin user architecture code



* .param VDD=1.8
.save

.control
	save all
	op
	* write CR_loads_jangarita.raw
	* print v(Iref10n) v(Iref1n) v(Iref1p) v(Iref10p)

	let VIref10n=v(Iref10n)
	let VIref1n=v(Iref1n)
	let VIref10p=v(Iref10p)
	let VIref1p=v(Iref1p)

	set wr_singlescale
	echo $&VIref10n $&VIref1n $&VIref10p $&VIref1p > CACE{simpath}/CACE{filename}_CACE{N}.data
	.endc





.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends

* expanding   symbol:  /foss/designs/chipathon_2025/designs/current_reference_load_v2/xschem/current_reference_load_v2.sym # of pins=8
** sym_path: designs/libs/current_reference_load_v2/xschem/current_reference_load_v2.sym
** sch_path: designs/libs/current_reference_load_v2/xschem/current_reference_load_v2.sch
.subckt current_reference_load_v2 Iref2n Iref50n Iref2p Iref50p VDD VSS Iref20n Iref20p
*.ipin Iref2n
*.iopin VDD
*.iopin VSS
*.ipin Iref50n
*.ipin Iref2p
*.ipin Iref50p
*.ipin Iref20p
*.ipin Iref20n
XM1 Iref2n Iref2n VDD VDD pfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM4 Iref2p Iref2p VSS VSS nfet_03v3 L=2u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM3 Iref50n Iref50n VDD VDD pfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=50
XM6 Iref50p Iref50p VSS VSS nfet_03v3 L=2u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=50
XM2 Iref20n Iref20n VDD VDD pfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
XM5 Iref20p Iref20p VSS VSS nfet_03v3 L=2u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
.ends

.GLOBAL GND
.end
